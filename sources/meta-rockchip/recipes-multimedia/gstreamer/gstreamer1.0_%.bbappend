PV="1.12.5"

SRC_URI[md5sum] = "1c49d15c0c76a4bf90a3ca723fdca43c"
SRC_URI[sha256sum] = "9f750d845a326880b24c1ccc913d07df8f38cd9e63009714795ae175b6c29c6a"
