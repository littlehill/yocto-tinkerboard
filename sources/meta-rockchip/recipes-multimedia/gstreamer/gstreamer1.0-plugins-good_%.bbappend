PV="1.12.5"

SRC_URI[md5sum] = "9459449dc1e8f26b73a62ae0c340e81b"
SRC_URI[sha256sum] = "2c84b23bbe06e40c99dece5ea4520b337a15aa4e7eba1290e6d14834e2005555"
